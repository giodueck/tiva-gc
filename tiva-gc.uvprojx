# Keil uVision project tiva-gc.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tiva-gc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: ENERGIA
  c misc: -Wno-implicit-int-float-conversion -Wno-implicit-int-conversion -Wno-float-conversion -Wno-pedantic -Wno-sign-conversion
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c InitGPIO.h InitGPIO.c Input.h Input.c LCD.h delay.s delay.h LCD.c delay.c tiva-gc.h tiva-gc-inc.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
